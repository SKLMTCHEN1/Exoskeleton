# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Source\APP;..\Source\STM32F10xLib\inc;..\Source\STM32F10xLib\M3;..\Source\Drive;..\Source\STM32F10xLib\startup;..\Source\STM32F10xLib;..\Source\STM32F10xLib\M3;..\Source\STM32F10xLib\src;..\Source\STM32F10xLib\inc;..\Source\Drive;..\Source\Drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../Source/APP/: Main.c
  group DRIVER
    ../Source/Drive/: delay.c lcd.c sys.c usart.c usart3.c can.c led.c usart2.c adc.c
  group FWLib
    ../Source/STM32F10xLib/M3/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c
    ../Source/STM32F10xLib/src/: system_stm32f4xx.c misc.c stm32f4xx_adc.c stm32f4xx_can.c
    ../Source/STM32F10xLib/startup/: startup_stm32f40_41xxx.s
software components: CMSIS:CORE 5.1.2
